FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-client-set-TLS-engine-and-keyform-before-mosquitto_t.patch"

